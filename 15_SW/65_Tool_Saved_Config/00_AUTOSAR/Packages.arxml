<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00046.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="9BE89B71-38A4-48A1-9924-4AB913D20EFB">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C0875DC7-D584-4092-9F2A-9BE5F773245A">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="47914CA8-3F50-4D12-93E7-F5914645F34C">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="BD2A254F-614B-4D3A-BE45-15F83F549227">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D4782EDF-A664-49E5-9508-3D565076F0A6">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D05B92DB-7650-45AF-AA21-8E283CB87927">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="045506C9-F3C2-4B8B-B59A-88BAA149E4E9">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="EFBA1C47-24C8-4ACF-B931-68F48196B7C2">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="4A1A2A0F-47E9-4067-910B-84DB836F5509">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2585BBC1-6113-4DC8-B86E-11C7F18B6753">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="45B78C46-F820-4012-B8EB-9390B81E41FA">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="341320F2-3673-4045-BE51-1B3701043C91">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D37551DD-D1FF-482C-80B6-CA6F7C80AA20">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="29264D16-04D8-4DF5-8343-D4F63B56D44B">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6CFB1FB8-2920-4931-BC9D-1D30946B73D8">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="C22587E0-7A18-47F3-BACB-4F3BE1520F76">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="21DFD913-5F39-48BD-A01E-CC8FB7A85FDF">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="1EEB3D4B-2A3E-4130-A2D2-1D19A5DE651F">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="BF8861C9-33D6-4B46-A140-34F99D9E8C98">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4BD407E9-9F19-4C84-BA6F-C6B29D5356B9">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="CA8CFEAC-DBF5-4350-AEC1-88C7C8DD9F19">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3643DC36-0C95-40CA-AB11-1714B44EAD4C">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0FE1A852-9071-41B5-85D1-91ACB371987F">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="AE9F391B-05D2-4A49-9A81-71F2665BB7DD">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7371408A-3E94-48EF-AC23-8D56985A2CB1">
      <SHORT-NAME>SwAddrMethods</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B5FB2E11-171A-4F73-9D92-D5FE3AF2C2C3">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="5E4F44A9-F81E-43A2-B52D-6A995AF268F6">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="EB5CF31C-C49C-4C79-9612-C0BE66A35A50">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="1AED2981-87FF-4961-8324-93B4FBCAA3D6">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A3959285-AD5C-49FB-93C1-6E793AE1F503">
      <SHORT-NAME>Units</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="FA70A647-0FE7-419E-B4DE-F0259897FB0D">
          <SHORT-NAME>COP</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>